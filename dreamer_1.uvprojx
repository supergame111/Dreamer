# Keil uVision project dreamer_1.uvprojx, settings and files
target dreamer (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.0.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: dreamer_1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: .\FWlib\inc;.\USER;.\CMSIS
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USERS
    ./USER/: main.c spi.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h systick.c ds1302.c key.c ADC.c filter.c mpu6050.c battery.c word.c usart_1.c IMUupdate.c IIC.c TIME2.c
  group CMSIS
    ./CMSIS/: core_cm3.c stm32f10x.h system_stm32f10x.c
    ./CMSIS/startup/: startup_stm32f10x_hd.s
  group LIB
    ./FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_usart.c stm32f10x_i2c.c
